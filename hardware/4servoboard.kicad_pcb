# Repository esehehelp/UART-FourServoControllBoard

File README.md:

# UART-FourServoControllBoard

## 概要 (Overview)

**UART-FourServoControllBoard** (以下UART-FSCB) は、わずか **22.82mm x 23.62mm** のサイズに、ロボットアーム制御に必要な機能をおおよそ詰め込んだ4軸スマートサーボコントローラ
従来のPCA9685等の単なるPWMドライバとは異なり、**電流・電圧・温度監視**、**USB-PD** 機能を搭載。MG996Rなどのハイパワーサーボ使用時でも、電流値と消費電力を監視しながら安全に駆動することが可能

## 特徴 (Features)

* **超小型サイズ:** 22.82mm x 23.62mm
* **USB PD対応:** CCピン制御により、モバイルバッテリーやPD充電器から電源を直接引き出し可能
  * 固定電圧 PDO に加え PPS (APDO) による電圧指定に対応 (`0x06` コマンド, mV 単位)
  * USB (CDC) 経由の通信対応
  * DLM (ブートローダ) 移行: `0xF0` コマンド、または背面の JP1 (DLM_JMP) をショート (R9 5.1k 経由で D+ をプルアップ)
    * USB経由の書き込み可能
* **電流監視機能:**
  * ローサイド電流検知回路を搭載（CH32X035内蔵OPA + 10mΩシャント抵抗）
  * ファームウェア内蔵の保護機能: 過電流・過電圧・過熱 (既定で有効)、低電圧・ストール検出 (任意) でサーボを停止し PC に通知
  * 閾値と有効/無効は GUI (デバイスパネル) またはコマンド `0x20` で変更可能
* **電圧監視機能**
  * 分圧抵抗によって電圧を監視可能
  * PPSと組み合わせたフィードバック制御も行う予定
* **温度監視**
  * NTCサーミスタによってVBUS-GNDに近い位置の温度計測が可能
* **PC用GUI** (`software/`)
  * Go + Wails (React) 製。USB 接続したボードを自動検出し、複数ボードから選択可能 (ボード名を設定可能)
  * 電圧・電流・温度・サーボフィードバックのリアルタイムプロット
  * サーボ 4ch / LED 2ch / USB-PD 電圧の操作、サーボ位置キャリブレーション
* **MCU:** WCH CH32X035F7P6 (RISC-V, 48MHz)
* **制御IF:** 1Wire-UART, USB
* **その他:**
  * 外部電源入出力ピンヘッダx2 (バッテリー駆動対応、BMS無し)
  * デイジーチェーン対応 (1Wire-UARTかつ電源ピン仕様時)
  * デバック用1.27ピンヘッダ搭載
  * 片面実装
  * 手ハンダ可能 (難易度は高い)
  * XC6206 LDOによる安定した3.3V系電源
    * より高耐圧な互換LDOによるさらなる高電圧対応

## 仕様 (Specifications)

| 項目 | 内容 |
| :--- | :--- |
| **MCU** | WCH CH32X035F7P6 (TSSOP-20) |
| **入力電圧** | USB VBUS (5V-20V) または EXT_IN (5V〜20V)。V0.8 は 3.3V LDO の入力耐圧のため USB-PD 要求をファームで 16.8V、GUI で 12V までに制限 (#38) |
| **ロジック電圧** | 3.3V (XC6206 LDO内蔵) |
| **出力チャンネル** | 4PWM |
| **通信** | 1-Wire UARTx2 (Default: 115200bps, 8N1) |
| **電流検知** | 0 〜 6.8A (Full Scale) |
| **コンデンサ** | 100uF / 35V (Polymer) + 22uF (Ceramic) |
| **基板サイズ** | 22.86mm x 23.62mm |

### サーボチャンネルとコネクタ

チャンネル番号はサーボコネクタ J3 のピン順・回路図のネット名 (PWM0〜3) と一致しません (J3 の 1 番ピンから **CH2 → CH1 → CH0 → CH3**)。

| J3 ピン | 回路図ネット | MCU ピン | チャンネル |
| :--- | :--- | :--- | :--- |
| 1 | PWM0/ADC0 | PA3 | CH2 |
| 2 | PWM1/ADC1 | PA1 | CH1 |
| 3 | PWM2/ADC2 | PA0 | CH0 |
| 4 | PWM3/ADC3 | PC1 | CH3 |

ピンアサインの詳細は [`docs/pinassign.md`](docs/pinassign.md)、回路定数は [`firmware/docs/constants.md`](firmware/docs/constants.md)。

## リポジトリ構成

| ディレクトリ | 内容 |
| :--- | :--- |
| `firmware/` | CH32X035 用ファームウェア (PlatformIO)。通信仕様は [`firmware/docs/PROTOCOL.md`](firmware/docs/PROTOCOL.md) |
| `software/` | PC 用 GUI (Go + Wails)。詳細は [`software/README.md`](software/README.md) |
| `uploader/` | USB 経由のファームウェア書き込みツール (Go、`pio run -t upload` から使用) |
| `hardware/` | KiCad 9.0 設計データ |

## 開発環境 (Development)

* **IDE:** Goland, CLion
* **Firmware:** PlatformIO (`platform = ch32v`)
* **Writer:** WCH-LinkE、または USB 経由 (DLM + wchisp)

### ファームウェアのビルド・書き込み

```bash
cd firmware
pio run                 # ビルド

# USB 経由の書き込み (WCH-LinkE 不要)
#   0xF0 で DLM に移行 -> BootROM を待つ -> wchisp flash (uploader/ を初回に go build)
pio run -t upload
pio run -t upload --upload-port /dev/ttyACM0   # ポートを指定する場合

# uploader を単体で使う場合
cd ../uploader && make && bin/uploader ../firmware/.pio/build/genericCH32X035F7P6/firmware.bin
```

### GUI のビルド

```bash
cd software
~/go/bin/wails build    # -> build/bin/servo-controller (Wails CLI が必要)
go test ./pkg/... ./test/...   # Go ユニットテスト
```

## 設計データ (Design Data)

* **EDA:** KiCad 9.0
* **PCB:** 2層基板 (1.6mm厚推奨)

## KiCad design hardware/4servoboard.kicad_pcb

Parts:
C1: 470uF/16V; CP_Elec_6.3x7.7; Rating V
C2, C4: 0.1u/50V; C_0603_1608Metric; Rating V
C3: 22u/10V; C_0603_1608Metric; Rating V
D1, D2: Red_1.7V; LED_0603_1608Metric
J1: USB_C_Receptacle; USB-C_16-HandSolder
J2: UART; PinHeader_1x04_P2.54mm_Vertical
J3: PWM; PinHeader_1x04_P2.54mm_Vertical
J4: V_SERVO; PinHeader_1x04_P2.54mm_Vertical
J5: GND; PinHeader_1x04_P2.54mm_Vertical
J6: EXT_POWER; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J7: DEBUG; PinHeader_1x02_P2.54mm_Vertical
JP1: DLM_JMP; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
Q1: AO3407A; SOT-23
Q2, Q3: BC857BSs; SOT-363_SC-70-6
Q4: SI2393DS; SOT-23
R1, R2, R13, R14: 22; R_0603_1608Metric
R3, R4: 5.1k; R_0603_1608Metric
R5, R6, R8, R11, R12: 1k; R_0603_1608Metric
R7, R9, R10, R16, R17, R18, R19: 5k1; R_0603_1608Metric
R15: 0.01; R_1206_3216Metric
TH1: 22k/B4050/NTC; R_0603_1608Metric
U1: CH32X035F7P6; TSSOP-20_4.4x6.5mm_P0.65mm
U2: ME6209A33M3G; SOT-23

Connections:
CC1: J1.A5 (CC1), R3.2, U1.2 (CC1/PC14)
CC2: J1.B5 (CC2), R4.2, U1.3 (CC2/PC15)
CURRENT_SENSE: J5.1, J5.2, J5.3, J5.4, R15.1, U1.13 (PA7)
D+: R1.2, R9.2, U1.18 (USB_DP/PC17)
D-: R2.2, U1.17 (USB_DM/PC16)
EXT_VIN: J6.1, Q3.1 (E1), Q4.3 (D)
GND: C1.2 (-), C2.1 (+), C3.2 (-), C4.2 (-), D2.1 (K), J1.GND, J1.S (SHIELD), J2.2, J2.3, J6.2, R3.1, R4.1, R8.2, R15.2, R16.2, R17.2, R18.2, R19.2, TH1.2, U1.15 (GND), U2.1 (GND)
MCU_LED1: R6.2, U1.1 (PB12)
MCU_LED2: D1.2 (A), U1.4 (RST/PC3)
unnamed: D1.1 (K), R5.2
unnamed: D2.2 (A), R6.1
unnamed: J1.A6 (D+), J1.B6 (D+), R1.1
unnamed: J1.A7 (D-), J1.B7 (D-), R2.1
unnamed: J2.1, R11.2, R13.1
unnamed: J2.4, R12.2, R14.1
unnamed: JP1.1 (A), R9.1
unnamed: Q1.1 (G), Q2.3 (C2), R17.1
unnamed: Q2.2 (B1), Q2.5 (B2), Q2.6 (C1), R16.1
unnamed: Q3.2 (B1), Q3.5 (B2), Q3.6 (C1), R18.1
unnamed: Q3.3 (C2), Q4.1 (G), R19.1
PWM0/ADC0: J3.1, U1.9 (PA3)
PWM1/ADC1: J3.2, U1.7 (PA1)
PWM2/ADC2: J3.3, U1.6 (PA0)
PWM3/ADC3: J3.4, U1.5 (PC1)
SWCLK: J7.1, U1.20 (SWCLK/PC19)
SWDIO: J7.2, U1.19 (SWDIO/PC18)
TEMP_SENSE: R10.2, TH1.1, U1.14 (PB1)
UART_A: R13.2, U1.8 (PA2)
UART_B: R14.2, U1.11 (PA5)
VBUS: J1.VBUS, Q1.3 (D), Q2.1 (E1)
VDD: C3.1 (+), C4.1 (+), JP1.2 (B), R5.1, R10.1, R11.1, R12.1, U1.16 (VDD), U2.2 (VO)
V_SENSE: R7.2, R8.1, U1.12 (PA6)
V_SERVO: C1.1 (+), C2.2 (-), J4.1, J4.2, J4.3, J4.4, Q1.2 (S), Q2.4 (E2), Q3.4 (E2), Q4.2 (S), R7.1, U2.3 (VI)

Notes on the sheet:
電圧計測
MCU
I/O
温度計測
LED
コネクタ
ダウンロードモード

Board: 4 copper layers, 23.4 x 30.3 mm, 40 parts (0 on the bottom side), 33 nets.

## Code that names these connections

File firmware/src/adc.h:

#ifndef ADC_H
#define ADC_H

#include "ch32x035.h"

/* --- ADC Channels --- */
#define ADC_CH_VSENSE    ADC_Channel_6  // PA6
#define ADC_CH_TEMPSENSE ADC_Channel_9  // PB1
#define ADC_CH_CURSENSE  ADC_Channel_4  // OPA2 Output (Internal PA4)

// Servo Feedback ADC Channels
#define ADC_CH_SERVO0    ADC_Channel_0  // PA0
#define ADC_CH_SERVO1    ADC_Channel_1  // PA1
#define ADC_CH_SERVO2    ADC_Channel_3  // PA3
#define ADC_CH_SERVO3    ADC_Channel_11 // PC1

extern volatile uint16_t g_servo_feedback[4];

void ADC_Init_Custom(void);
uint16_t Get_ADC_Val(uint8_t ch);
void Update_Servo_Feedback(void);

#endif

File firmware/src/adc.c:

#include "adc.h"
#include "ch32x035_opa.h"

volatile uint16_t g_servo_feedback[4] = {0};

void ADC_Init_Custom(void) {
    ADC_InitTypeDef ADC_InitStructure = {0};
    GPIO_InitTypeDef GPIO_InitStructure = {0};
    OPA_InitTypeDef OPA_InitStructure = {0};

    // 1. Enable Clocks
    RCC_APB2PeriphClockCmd(RCC_APB2Periph_GPIOA | RCC_APB2Periph_GPIOB | RCC_APB2Periph_GPIOC | RCC_APB2Periph_ADC1, ENABLE);
    RCC_APB2PeriphClockCmd(RCC_APB2Periph_AFIO, ENABLE);
    RCC->APB2PCENR |= (1 << 22); // OPA Clock

    // 2. Set ADC Clock
    ADC_CLKConfig(ADC1, ADC_CLK_Div6);

    // 3. Standard Sensor GPIO Setup
    GPIO_InitStructure.GPIO_Pin = GPIO_Pin_6 | GPIO_Pin_7; // PA6=V_SENSE, PA7=I_SENSE(+)
    GPIO_InitStructure.GPIO_Mode = GPIO_Mode_AIN;
    GPIO_Init(GPIOA, &GPIO_InitStructure);

    GPIO_InitStructure.GPIO_Pin = GPIO_Pin_1; // PB1=T_SENSE
    GPIO_Init(GPIOB, &GPIO_InitStructure);

    // PA4 (OPA2 Output / ADC_IN4)
    GPIO_InitStructure.GPIO_Pin = GPIO_Pin_4;
    GPIO_Init(GPIOA, &GPIO_InitStructure);

    // 4. OPA2 Initialization (PGA x32)
    OPA_Unlock();
    OPA_InitStructure.OPA_NUM = OPA2;
    OPA_InitStructure.Mode = OUT_IO_OUT0; // Output to PA4 (Internal/ADC), frees PA2
    OPA_InitStructure.PSEL = CHP0;        // PA7 (OPA2_P0)
    OPA_InitStructure.NSEL = CHN_PGA_32xIN; // Internal PGA x32, disconnects PA5 (OPA2_N0)
    OPA_InitStructure.FB   = FB_ON;
    OPA_Init(&OPA_InitStructure);
    OPA_Cmd(OPA2, ENABLE);
    OPA_Lock();

    // 5. ADC Initialization
    ADC_DeInit(ADC1);
    ADC_InitStructure.ADC_Mode = ADC_Mode_Independent;
    ADC_InitStructure.ADC_ScanConvMode = DISABLE;
    ADC_InitStructure.ADC_ContinuousConvMode = DISABLE;
    ADC_InitStructure.ADC_ExternalTrigConv = ADC_ExternalTrigConv_None;
    ADC_InitStructure.ADC_DataAlign = ADC_DataAlign_Right;
    ADC_InitStructure.ADC_NbrOfChannel = 1;
    ADC_Init(ADC1, &ADC_InitStructure);
    
    ADC_Cmd(ADC1, ENABLE);

    // 6. Calibration
    ADC1->CTLR2 |= (1 << 3); while(ADC1->CTLR2 & (1 << 3));
    ADC1->CTLR2 |= (1 << 2); while(ADC1->CTLR2 & (1 << 2));
}

uint16_t Get_ADC_Val(uint8_t ch) {
    ADC_RegularChannelConfig(ADC1, ch, 1, ADC_SampleTime_11Cycles);
    ADC_SoftwareStartConvCmd(ADC1, ENABLE);
    while(!ADC_GetFlagStatus(ADC1, ADC_FLAG_EOC));
    return ADC_GetConversionValue(ADC1);
}

void Update_Servo_Feedback(void) {
    GPIO_InitTypeDef GPIO_InitStructure = {0};

    // Keep interrupts (USB command handling calls Set_Servo) out while the
    // PWM pins are switched to analog input (#12). ~60 us, shorter than one
    // UART byte at 115200 bps (~87 us).
    __disable_irq();

    // 1. Temporarily switch pins to AIN (Analog Input)
    GPIO_InitStructure.GPIO_Mode = GPIO_Mode_AIN;
    GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
    
    GPIO_InitStructure.GPIO_Pin = GPIO_Pin_0 | GPIO_Pin_1 | GPIO_Pin_3;
    GPIO_Init(GPIOA, &GPIO_InitStructure);
    
    GPIO_InitStructure.GPIO_Pin = GPIO_Pin_1;
    GPIO_Init(GPIOC, &GPIO_InitStructure);

    // Settling delay
    Delay_Us(10);

    // 2. Sample Each Channel
    g_servo_feedback[0] = Get_ADC_Val(ADC_CH_SERVO0);
    g_servo_feedback[1] = Get_ADC_Val(ADC_CH_SERVO1);
    g_servo_feedback[2] = Get_ADC_Val(ADC_CH_SERVO2);
    g_servo_feedback[3] = Get_ADC_Val(ADC_CH_SERVO3);

    // 3. Restore to AF_PP (Alternative Function Push-Pull for TIM)
    GPIO_InitStructure.GPIO_Mode = GPIO_Mode_AF_PP;
    
    GPIO_InitStructure.GPIO_Pin = GPIO_Pin_0 | GPIO_Pin_1 | GPIO_Pin_3;
    GPIO_Init(GPIOA, &GPIO_InitStructure);
    
    GPIO_InitStructure.GPIO_Pin = GPIO_Pin_1;
    GPIO_Init(GPIOC, &GPIO_InitStructure);

    __enable_irq();
}

## Commit log (part)

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2025-12-24 fix. ディレクトリ編成の大幅変更
2025-12-26 fix: README更新
2025-12-26 fix: ディレクトリ構成の変更に伴うパス修正
2025-12-26 fix: ディレクトリ構成の変更に伴うgitignoreの更新
2025-12-26 update: README.mdの全体的な更新と新機能の記述の追加
2026-01-29 wip: Rev0.4への更新
2026-01-29 delete: 一部ファイルの削除
2026-01-29 fix: ファイル名変更に伴う.gitignore更新
2026-01-29 feat: V0.4移行、電源回路の強化
2026-01-29 fix: V0.4移行に伴う部品構成の変更
2026-01-29 fix: typo修正
2026-02-07 Update: V0.6移行に伴い，四層基板ヘ移行．エラッタ修正，Pch逆接保護回路追加，5.08端子追加
2026-02-08 Fix: 基板デザインの効率化が主．内容：アートワークの最適化，viaの追加など
2026-02-09 Update: V0.7移行．ORing回路実装，電源設計の効率化，回路定数の見直し
2026-02-14 Update: V0.8移行．回路設計の効率化．エラッタの修正
2026-02-20 feat: ひとまずpwm生成できるように
2026-02-21 Add USB PD PPS support header
2026-02-21 Implement USB PD PPS support with automatic 5V request on startup
2026-02-21 Configure dual 1-Wire UART (USART2 on PA2, USART4 on PA5) with correct remapping
2026-02-21 Update UART header for dual 1-Wire UART and system initialization
2026-02-21 Configure OPA2 to avoid PA2/PA5 conflicts and use internal ADC output
2026-02-21 Add Set Voltage command (0x06) and implement packet forwarding for ring bus
2026-02-21 Add IF_UART4 to protocol interfaces
2026-02-21 Integrate USB PD processing and dual UART polling into main loop
2026-02-21 Remove UART conflicts from servo initialization
2026-02-21 Document Blink LED (0x05) and Set Voltage (0x06) commands
2026-02-21 Enhance GUI with safe voltage control, Kalman/Median filters, and 30ms polling
2026-02-21 Add remaining source files and drivers
2026-02-21 Add documentation and test scripts
2026-02-21 Update platformio.ini with project configurations
2026-02-22 Implement LED pattern playback, fix buffer overflows, and reorganize driver library
2026-02-22 Finalize firmware with stable TIM3 timing, correct UART remapping, and updated Japanese documentation
2026-02-22 fix: ディレクトリの修正
2026-02-22 fix: 勝手に消された内容の復元
2026-02-27 fix: resolve UART-A (PA2) pin conflict and PA3 PWM noise interference
2026-02-27 checkpoint: UART-B RX works, but TX and UART-A are failing
2026-03-11 feat: add servo position feedback via ADC during PWM idle periods
    - Implement Update_Servo_Feedback() to sample PA0, PA1, PA3, PC1 as ADC
    - Switch GPIO mode between AF_PP and AIN during PWM low periods (10ms offset)
    - Extend protocol 0x02 (Read Sensors) response from 7 to 15 bytes to include feedback
    - Update gui_control.py to display real-time feedback voltage for each channel
    - Update PROTOCOL.md to v2.2 reflecting packet structure changes
